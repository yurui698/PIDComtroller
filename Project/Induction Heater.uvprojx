# Keil uVision project Induction Heater.uvprojx, settings and files
target Control (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Induction Heater +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\Libraries\inc;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\User\inc;..\Output
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\Output\Induction Heater.sct
  group StartUp
    ../Libraries/startup/: startup_stm32f10x_md.s
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_spi.c stm32f10x_i2c.c
    ../User/src/: SST25VF016B.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_it.c systemclock.c HandleTask.c si4463.c
    ../User/src/: Stm32_Configuration.c DataFlash.c
